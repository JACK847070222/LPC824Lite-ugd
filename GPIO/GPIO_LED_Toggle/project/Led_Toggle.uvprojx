# Keil uVision project Led_Toggle.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.4.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Led_Toggle
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user\inc;..\common\inc;..\driver\inc;..\peripherals_lib
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group User
    ../user/src/: main.c interrupt.c system_LPC8xx.c
  group Startup
    ../common/src/: Keil_startup_LPC8xx.s
  group Driver
    ../driver/src/: user_gpio.c user_systick.c
